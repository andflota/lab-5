options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: segunda_parte
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: d1
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: d2
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: ModulosEfren_Compara_0
  id: ModulosEfren_Compara
  parameters: {}
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '10000'
    offset: '-1'
    phase: '0'
    samp_rate: d2
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: d1
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: parameter_0
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: d1
    type: float
  states: {}

connections:
- [ModulosEfren_Compara_0, '0', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0, '0', ModulosEfren_Compara_0, '1']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0_0, '0', ModulosEfren_Compara_0, '0']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
